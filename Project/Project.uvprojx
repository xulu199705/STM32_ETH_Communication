# Keil uVision project Project.uvprojx, settings and files
target STM32F107VC (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c misc: --diag_suppress 236
  c include: ..\Project;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\I2C_EE;..\User\IT;..\User\NetConf;..\User\System;..\User\TouchScreen;..\User\USART;..\User;..\Utilities\lwip-1.3.1\port;..\Utilities\lwip-1.3.1\src\include;..\Utilities\lwip-1.3.1\src\include\ipv4;..\Utilities\lwip-1.3.1\src\include\lwip;..\Utilities\efsl\include;..\Utilities\efsl\include\interface;..\Libraries\STM32_ETH_Driver\inc;..\Utilities\STM32_EVAL;..\Utilities\STM32_EVAL\STM3210C_EVAL;..\User\Key;..\Utilities\lwip-1.3.1\src\core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
    ../User/I2C_EE/: i2c_ee.c
    ../User/IT/: stm32f10x_it.c
    ../User/NetConf/: netconf.c
    ../User/System/: stm32f107.c
    ../User/USART/: usart.c
    ../Utilities/lwip-1.3.1/port/: client.c helloworld.c server.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group STM32_EVAL
    ../Utilities/STM32_EVAL/: stm32_eval.c
    ../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_ioe.c stm3210c_eval_lcd.c
  group LwIP
    ../Utilities/lwip-1.3.1/port/: ethernetif.c
    ../Utilities/lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../Utilities/lwip-1.3.1/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
    ../Utilities/lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group efsl
    ../Utilities/efsl/source/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
    ../Utilities/efsl/source/interface/: sd.c sd_stm32.c
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK_start_code
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Doc
    ../: README.txt
